# Keil uVision project Tester.uvproj, settings and files
target Tester (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Tester
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;.\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Source/: ADCSWTrigger.c PLL.c Tester.c Timer0.c UART2.c
  group Startup
    ./Startup/: startup.s
  group Headers
    ./Headers/: ADCSWTrigger.h FIFO.h lm4f120h5qr.h PLL.h Timer0.h UART2.h
